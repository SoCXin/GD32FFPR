# Keil uVision project Project.uvprojx, settings and files
target GD32FFPR_SWD (ARM-ADS)
  device: GD32FFPRTG GigaDevice
  pack: GigaDevice.GD32FFPR_DFP.1.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_SWD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD,DEBUG_PRINTF
  c misc: --c99
  c include: Firmware\CMSIS;Firmware\CMSIS\GD\GD32F30x\Include;Firmware\GD32F30x_standard_peripheral\Include;UserCode\inc;Hardware;.\ExternLib\TfpsLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group CMSIS
    Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Appliction
    UserCode/src/: main.c gd32f30x_it.c
    ./UserCode/src/: tfps_app.c leds_app.c
  group Firmware
    Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Hardware
    Hardware/: systick.c timer.c uart.c
  group TfpsLib
    ./ExternLib/TfpsLib/: tfpslibGD.lib tfpslibGDusb.lib
target GD32FFPR_USB (ARM-ADS)
  device: GD32FFPRTG GigaDevice
  pack: GigaDevice.GD32FFPR_DFP.1.0.0
  cpu: as above
  output: Project_USB +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD,DEBUG_PRINTF,USB_DOWNLOAD
  c misc: --c99
  c include: Firmware\CMSIS;Firmware\CMSIS\GD\GD32F30x\Include;Firmware\GD32F30x_standard_peripheral\Include;.\Firmware\GD32F30x_usbd_driver\Include;UserCode\inc;Hardware;.\ExternLib\TfpsLib
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x20000
